# Repository onedge-dev/kiss_alyser

File README.md:

# KISS alyser

## Table of contents
* [General info](#general-info)
* [Technologies](#technologies)
* [Setup](#setup)
* [Important mentions](#important-mentions)
<br><br>

## General info
Keep it simple, stupid principle based logic analyser.
```
"An idiot admires complexity, a genius admires simplicity, ..."
  -Terry A Davis
```
This project is based on the amazing work of the [fx2grok](https://sigrok.org/wiki/Fx2grok) team.<br><br>
The device we made is supposed to be a cost effective logic analyser with 16 channels. Cheap chinese analyser can be bought for less than $10 online. However, the chips are usually fake and run hot. They are also generally limited to 8 channels. This analyser can use the full 16 channels supported by the chip as long as the total sampling speed is below 192 million samples per second.
<br><br><br>

## Technologies
Project is created with:
- KiCad v5.1.12
<br><br><br>

## Setup
To use this device you will need pulseview to view and measure your connections, you can download the software [here](https://sigrok.org/wiki/Downloads).  
After the installation, plug in your analyser and start the software. It should automatically detect your device and it's capabilities. If it is not recognized, you can choose the *fx2lafw (generic driver for FX2 based LAs)* under drivers. Select USB as the connection interface and select the correct device under *Select the device*. You can now start using the logic analyser to sample data.  
You can find more information in the following links:<br><br>
pulseview manual: https://sigrok.org/doc/pulseview/0.4.1/manual.pdf  
general pulseview information: https://sigrok.org/wiki/PulseView  
supported decoders: https://sigrok.org/wiki/Protocol_decoders
<br><br><br>

## Important mentions
- Make sure to use a USB port or hub that is capable of delivering the full 480MHz needed for the device.
- The total bandwidth of the device is limited to 192 million samples per second.

## KiCad design HW/MASTER/easy_analyser.kicad_pcb

Parts:
C1, C4, C5, C10, C11: 1uF; C_0603
C2, C3: 18pF; C_0603
C6, C7, C8, C9, C12, C13, C14, C15, C16: 100nF; C_0603
J1: USB-C_GCT_USB4105-GF-A; GCT_USB4105
J2: header_02x10_male; WURTH_61202021721
J3: header_01x02_male; HDRVTH2P2.54_1x02
LD1, LD2: LED; LD_0603
R1, R2, R3, R4: 100k; BOURNS_CAY16-J4_1206-4
R5, R6, R7, R8, R9, R12, R13: 2k7; R_0603
R10, R11: 5k1; R_0603
U1, U2: IP425x-8; DFN3.30X1.35X0.55-16
U3: CY7C68013A; QFN0.5P8.00X8.00X0.90-56
U4: MIC5317; SOT230.9P2.7X2.9-5
U5: 24LC01; MSOP0.65P6.40X1.20-8
Y1: 24MHz; XTAL3.20X2.50X0.80

Connections:
+3V3: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, LD1.2 (A), R1.1, R1.2, R1.3, R1.4, R2.1, R2.2, R2.3, R2.4, R3.1, R3.2, R3.3, R3.4, R4.1, R4.2, R4.3, R4.4, R5.1, R6.1, R7.1, R8.2, R9.2, U3.3 (AVCC), U3.7 (AVCC), U3.11 (VCC), U3.17 (VCC), U3.27 (VCC), U3.32 (VCC), U3.43 (VCC), U3.55 (VCC), U4.5 (Vout), U5.8 (VCC)
/PA1: LD2.2 (A), U3.34 (PA1)
/PB0: R1.8, U1.1 (I/O), U3.18 (PB0)
/PB1: R1.7, U1.2 (I/O), U3.19 (PB1)
/PB2: R1.6, U1.3 (I/O), U3.20 (PB2)
/PB3: R1.5, U1.4 (I/O), U3.21 (PB3)
/PB4: R2.8, U1.5 (I/O), U3.22 (PB4)
/PB5: R2.7, U1.6 (I/O), U3.23 (PB5)
/PB6: R2.6, U1.7 (I/O), U3.24 (PB6)
/PB7: R2.5, U1.8 (I/O), U3.25 (PB7)
/PD0: R3.8, U2.1 (I/O), U3.45 (PD0)
/PD1: R3.7, U2.2 (I/O), U3.46 (PD1)
/PD2: R3.6, U2.3 (I/O), U3.47 (PD2)
/PD3: R3.5, U2.4 (I/O), U3.48 (PD3)
/PD4: R4.8, U2.5 (I/O), U3.49 (PD4)
/PD5: R4.7, U2.6 (I/O), U3.50 (PD5)
/PD6: R4.6, U2.7 (I/O), U3.51 (PD6)
/PD7: R4.5, U2.8 (I/O), U3.52 (PD7)
/SCL: J3.2, R6.2, U3.15 (SCL), U5.6 (SCL)
/SDA: J3.1, R7.2, U3.16 (SDA), U5.5 (SDA)
/USB_N: J1.A7 (D-), J1.B7 (D-), U3.9 (DMINUS)
/USB_P: J1.A6 (D+), J1.B6 (D+), U3.8 (DPLUS)
/XTALIN: C3.2, U3.5 (XTALIN), Y1.3 (X2)
/XTALOUT: C2.2, U3.4 (XTALOUT), Y1.1 (X1)
/_PB0: J2.3, U1.16 (I/O)
/_PB1: J2.4, U1.15 (I/O)
/_PB2: J2.5, U1.14 (I/O)
/_PB3: J2.6, U1.13 (I/O)
/_PB4: J2.7, U1.12 (I/O)
/_PB5: J2.8, U1.11 (I/O)
/_PB6: J2.9, U1.10 (I/O)
/_PB7: J2.10, U1.9 (I/O)
/_PD0: J2.11, U2.16 (I/O)
/_PD1: J2.12, U2.15 (I/O)
/_PD2: J2.13, U2.14 (I/O)
/_PD3: J2.14, U2.13 (I/O)
/_PD4: J2.15, U2.12 (I/O)
/_PD5: J2.16, U2.11 (I/O)
/_PD6: J2.17, U2.10 (I/O)
/_PD7: J2.18, U2.9 (I/O)
/~RST: C1.2, R8.1, U3.42 (RESET#)
/~WKP: R9.1, U3.44 (WAKEUP)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.1, J2.2, J2.19, J2.20, R10.1, R11.1, R12.2, R13.2, U1.EP (GND), U2.EP (GND), U3.6 (AGND), U3.10 (AGND), U3.12 (GND), U3.14 (Reserved/GND), U3.26 (GND), U3.28 (GND), U3.41 (GND), U3.53 (GND), U3.56 (GND), U3.EP (GND), U4.2 (GND), U5.1 (A0), U5.2 (A1), U5.3 (A2), U5.4 (GND), U5.7 (~WP), Y1.2 (GND), Y1.4 (GND)
unnamed: J1.A5 (CC1), R11.2
unnamed: J1.B5 (CC2), R10.2
unnamed: LD1.1 (C), R12.1
unnamed: LD2.1 (C), R13.1
unnamed: R5.2, U3.1 (RDY0)
Vbus: C10.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U4.1 (Vin), U4.3 (EN)

Notes on the sheet:
USB shield is not connected, this connection should be made by the host device.
Feedback LEDs
Power regulation
USB connectivity
EZ USB FX2
The RED LED will indicate if the power is present. The GREEN LED will light up when channel 0 is high.
Input protection
Input connector
FX2 decoupling
100nF for each VDD pin + 1uF for each VDDA pin.
Crystal oscillator
Total current consumtion is estimated at 100mA. The LDO can provide 150mA, and dissipate (0.1A*(5v-3.3v)=)0.17W Pmax=(Tmax - Tamb)/Θja => Tmax = (P * Θja) + Tamb => Tmax = (0.17W * 253°C/W) + 25°C = 68°C
EEPROM VIP/PID/DID 1D50:608D:xxxx ADDRESS:VALUE => 0x00:0xC0, 0x01:0x50 , 0x02:0x1D , 0x03:0x8D , 0x04:0x60 , 0x05:0x__ , 0x06:0x__ , 0x07:0x00
EEPROM

Board: 2 copper layers, 49.0 x 33.0 mm, 63 parts (21 on the bottom side), 49 nets.

Other parts of the board:
kibuzzard-6225F7B7, kibuzzard-62260CDD, kibuzzard-62260CDD#2, kibuzzard-62260CFE, kibuzzard-62260D3A, kibuzzard-62260D3E, kibuzzard-62260D4A, kibuzzard-62260D32, kibuzzard-62260D47, kibuzzard-62260DE2, kibuzzard-62260E22, kibuzzard-62260EB8, kibuzzard-62260EDB, kibuzzard-62260EDB#2, kibuzzard-62260EE7, kibuzzard-62260EEB, kibuzzard-62260EEF, kibuzzard-62260EF2, kibuzzard-62260EF7, kibuzzard-62260EFA, kibuzzard-62260EFF, kibuzzard-62261D1D, kibuzzard-62261D22: G***; label

## Commit log

2022-02-28 initial
2022-03-07 Finished schematic and footprint creation
2022-03-07 Associated symbols with footprints
2022-03-07 Finished PCB design
2022-03-07 Fixed library reference
2022-03-07 Fixed the revision number in the schematic
2022-03-07 Added the schematic in .pdf format for browser previews
2022-03-14 last push with changes before the presentation
2022-03-14 added readme
2022-03-14 Updated the readme file
2022-03-15 Made changes for better fabrication (0.125mm tracks)
2022-03-16 Updated all tracks to be at least 0.15mm, made vias 0.7mm with a 0.3mm drill and added teardrops
